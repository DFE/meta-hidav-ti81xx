
PR_append = "+r0"
COMPATIBLE_MACHINE_hidav-ti81xx = "hidav-ti81xx"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_hidav-ti81xx = " file://2.6.37-compat.patch "

